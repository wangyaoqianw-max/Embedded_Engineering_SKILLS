# Keil uVision project Board.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: ARM.CMSIS.5.2.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") CLOCK(8000000) ESEL ELITTLE
  output: Board
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Core/Src/: main.c startup.s
target Release (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: ARM.CMSIS.5.2.1-dev1
  cpu: as above
  output: Board
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
